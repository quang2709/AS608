# IAR project SM_LOCK.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: USE_STDPERIPH_DRIVER; STM8L05X_HD_VL
  ICCSTM8.CCIncludePath2: C:\Users\Lenovo\Desktop\Zigbee\SmDoor\App; C:\Users\Lenovo\Desktop\Zigbee\SmDoor\Driver; C:\Users\Lenovo\Desktop\Zigbee\SmDoor\Lib\inc; C:\Users\Lenovo\Desktop\Zigbee\SmDoor\Mid\ncp; C:\Users\Lenovo\Desktop\Zigbee\SmDoor\Mid\debug; C:\Users\Lenovo\Desktop\Zigbee\SmDoor\Mid\fingerprint; C:\Users\Lenovo\Desktop\Zigbee\SmDoor\Mid\common; C:\Users\Lenovo\Desktop\Zigbee\SmDoor\User
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: SM_LOCK.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group App
    ../App/: fingerprint_app.c zb_command.c
  group Driver
    ../Driver/: timer.c uart.c
  group Lib
    ../Lib/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_delay.c stm8l15x_display.c stm8l15x_dma.c stm8l15x_drivermotor.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group Mid/Common
    ../Mid/common/: queue.c xor.c
  group Mid/Debug
    ../Mid/debug/: debug.c
  group Mid/FingerPrint
    ../Mid/fingerprint/: fingerprint.c
  group Mid/NCP
    ../Mid/ncp/: ncp.c
  group User
    ../User/: main.c stm8l15x_it.c
